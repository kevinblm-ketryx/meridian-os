SUMMARY = "Meridian base image"
IMAGE_INSTALL += "meridian-agent meridian-telemetry"
